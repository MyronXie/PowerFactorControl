# Keil uVision project LQB-Project2.uvprojx, settings and files
target PFC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PFC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\inc;..\Libraries\src;..\Libraries;..\Libraries\STM32F10x_DSP_Lib\inc;..\Libraries\STM32F10x_DSP_Lib\src;..\Libraries\STM32F10x_DSP_Lib\src\asm\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Lib
    ../Libraries/: core_cm3.c system_stm32f10x.c
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Libraries/: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c gpio.c systick.c usart.c lcd.c tim.c adc.c PFMeasure.c dac.c
  group DSP-Library
    ../Libraries/STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
    ../Libraries/STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_256_stm32.s
